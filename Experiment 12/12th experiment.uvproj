# Keil uVision project 12th experiment.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 12th experiment
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: exp 12.c
